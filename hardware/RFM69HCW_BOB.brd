File: hardware/RFM69HCW_BOB.brd (EAGLE design)
At the start: 27.9 x 20.3 mm, 13 parts, among them U1 RFM69HCW

Commit message: cleanup for reds
Parts:
- moved LOGO2 0.32 mm to (14.0, 11.1)
